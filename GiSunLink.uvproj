# Keil uVision project GiSunLink.uvproj, settings and files
target GiSunLink (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: GiSunLink +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Library\Include;
  group Code
    ./Code/: main.c gisunlink_peripheral.c gisunlink_common.c gisunlink_eeprom.c gisunlink_screen.c gisunlink_system.c gisunlink_event.c gisunlink_timer.c gisunlink_beep.c gisunlink_task.c gisunlink_key.c gisunlink_tension.c
  group Startup
    ./Library/Startup/: STARTUP.A51
